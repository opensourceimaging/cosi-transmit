<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>inversion_recovery</value></param>
<param><key>title</key><value>Inversion Recovery</value></param>
<param><key>author</key><value>Chris Hasselwander</value></param>
<param><key>description</key><value>Inversion Recovery Imaging Sequence</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RUN</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ex_delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slave_delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gx_delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gx_on</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gz_delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Gy_delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gy_on</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>master_delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>readout_delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ref_delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gz_on</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TR</value></param>
<param><key>value</key><value>1.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TR_clock</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>power</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CF</value></param>
<param><key>value</key><value>21.3e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gx_nav</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TI_delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>length</key><value>10</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>max_iter</key><value>4000</value></param>
</block>
<block>
<key>MRI_triggered_vector_source</key>
<param><key>id</key><value>ex_pulse</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>data</key><value>[0,0,0]</value></param>
<param><key>startamp</key><value>1.0</value></param>
<param><key>deltaamp</key><value>0.0</value></param>
<param><key>namps</key><value>1</value></param>
<param><key>namprepeat</key><value>1</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_2</value></param>
<param><key>low</key><value>.000001</value></param>
<param><key>high</key><value>.000001</value></param>
<param><key>init</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
<param><key>freq</key><value>1./TR</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>s_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>5</value></param>
</block>
<block>
<key>MRI_triggered_vector_source</key>
<param><key>id</key><value>readwin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>data</key><value>[0,0,0]</value></param>
<param><key>startamp</key><value>1.0</value></param>
<param><key>deltaamp</key><value>0.0</value></param>
<param><key>namps</key><value>1</value></param>
<param><key>namprepeat</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>s_delay</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>int(slave_delay)</value></param>
<param><key>num_ports</key><value>2</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>s_delay_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>5</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_2</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>s_delay_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>5</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>gy_on</value></param>
</block>
<block>
<key>MRI_triggered_vector_source</key>
<param><key>id</key><value>Gy</value></param>
<param><key>type</key><value>float</value></param>
<param><key>data</key><value>[0,0,0]</value></param>
<param><key>startamp</key><value>1</value></param>
<param><key>deltaamp</key><value>0</value></param>
<param><key>namps</key><value>1</value></param>
<param><key>namprepeat</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>gz_on</value></param>
</block>
<block>
<key>MRI_triggered_vector_source</key>
<param><key>id</key><value>Gz</value></param>
<param><key>type</key><value>float</value></param>
<param><key>data</key><value>[0,0,0]</value></param>
<param><key>startamp</key><value>1</value></param>
<param><key>deltaamp</key><value>0</value></param>
<param><key>namps</key><value>1</value></param>
<param><key>namprepeat</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>gx_on</value></param>
</block>
<block>
<key>MRI_triggered_vector_source</key>
<param><key>id</key><value>Gx</value></param>
<param><key>type</key><value>float</value></param>
<param><key>data</key><value>[0,0,0]</value></param>
<param><key>startamp</key><value>1</value></param>
<param><key>deltaamp</key><value>0</value></param>
<param><key>namps</key><value>1</value></param>
<param><key>namprepeat</key><value>1</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>alpha</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>3000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>ymin</key><value>-.25</value></param>
<param><key>ymax</key><value>.25</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>update_time</key><value>.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>tr_level</key><value>.01</value></param>
<param><key>label1</key><value>Read Window</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>style1</key><value>2</value></param>
<param><key>label2</key><value>Real Signal</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label3</key><value>Imag Signal</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>label4</key><value>RMS</value></param>
<param><key>color4</key><value>"green"</value></param>
<param><key>style4</key><value>2</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_1</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>low</key><value>.01</value></param>
<param><key>high</key><value>.01</value></param>
<param><key>init</key><value>0</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_0</value></param>
<param><key>low</key><value>.01</value></param>
<param><key>high</key><value>.01</value></param>
<param><key>init</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>delay</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>5</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>m_delay</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>int(master_delay)</value></param>
<param><key>num_ports</key><value>2</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>sync_data</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>rf_sink</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:AB B:AB</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>CF+offset</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>A:AB</value></param>
<param><key>center_freq1</key><value>0</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>ant1</key><value>B:AB</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>dc_sinc</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>B:AB A:AB</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>B:AB</value></param>
<param><key>center_freq1</key><value>0</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>ant1</key><value>A:AB</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:A B:B</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>CF+offset</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>A:A</value></param>
<param><key>bw0</key><value>25000</value></param>
<param><key>center_freq1</key><value>CF+offset</value></param>
<param><key>gain1</key><value>10</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>ant1</key><value>B:B</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>B:A B:B</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>B:A</value></param>
<param><key>center_freq1</key><value>0</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>ant1</key><value>B:B</value></param>
</block>
<block>
<key>MRI_gated_vector_sink</key>
<param><key>id</key><value>signal_out</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0_1</value></param>
<param><key>low</key><value>.05</value></param>
<param><key>high</key><value>.05</value></param>
<param><key>init</key><value>0</value></param>
</block>
<block>
<key>MRI_triggered_vector_source</key>
<param><key>id</key><value>syncwin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>data</key><value>[1,1,1,1,1,1,1,1,1,1]</value></param>
<param><key>startamp</key><value>1.0</value></param>
<param><key>deltaamp</key><value>0.0</value></param>
<param><key>namps</key><value>1</value></param>
<param><key>namprepeat</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>7</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>MRI_gated_vector_sink</key>
<param><key>id</key><value>signal_out_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>6</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
<param><key>freq</key><value>3./TR</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>MRI_triggered_vector_source</key>
<param><key>id</key><value>ref_pulse</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>data</key><value>[0,0,0]</value></param>
<param><key>startamp</key><value>1.0</value></param>
<param><key>deltaamp</key><value>0.0</value></param>
<param><key>namps</key><value>1</value></param>
<param><key>namprepeat</key><value>1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>delay1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>ex_delay</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>delay1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>ref_delay</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>delay3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>readout_delay</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>delay6</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>Gx_delay</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>delay3_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>Gy_delay</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>delay3_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>Gz_delay</value></param>
</block>
<block>
<key>MRI_triggered_vector_source</key>
<param><key>id</key><value>ir_ref_pulse</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>data</key><value>[0,0,0]</value></param>
<param><key>startamp</key><value>1.0</value></param>
<param><key>deltaamp</key><value>0.0</value></param>
<param><key>namps</key><value>1</value></param>
<param><key>namprepeat</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>RUN</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>inv_delay_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>TI_delay</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>inv_delay_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>TI_delay</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>inv_delay_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>TI_delay</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>inv_delay_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>TI_delay</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>inv_delay</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>TI_delay</value></param>
</block>
<connection><source_block_id>delay1</source_block_id><sink_block_id>ex_pulse</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ex_pulse</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_threshold_ff_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay1_0</source_block_id><sink_block_id>ref_pulse</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay3</source_block_id><sink_block_id>readwin</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>s_delay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>s_delay</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s_delay_0</source_block_id><sink_block_id>dc_sinc</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s_delay_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>readwin</source_block_id><sink_block_id>s_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s_delay_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s_delay</source_block_id><sink_block_id>s_delay_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s_delay</source_block_id><sink_block_id>dc_sinc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_2</source_block_id><sink_block_id>blocks_float_to_complex_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>syncwin</source_block_id><sink_block_id>blocks_float_to_complex_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>delay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_2</source_block_id><sink_block_id>m_delay</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>m_delay</source_block_id><sink_block_id>rf_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>m_delay</source_block_id><sink_block_id>rf_sink</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>syncwin</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Gy</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Gz</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay3_0_1</source_block_id><sink_block_id>Gz</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay3_0_1_0</source_block_id><sink_block_id>Gy</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Gx</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay6</source_block_id><sink_block_id>Gx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>s_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>syncwin</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_rms_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_rms_xx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_1</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_threshold_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_rms_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>signal_out</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1</source_block_id><sink_block_id>signal_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>sync_data</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>delay</source_block_id><sink_block_id>m_delay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>signal_out_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0_1</source_block_id><sink_block_id>signal_out_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>signal_out_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ref_pulse</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ir_ref_pulse</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>inv_delay</source_block_id><sink_block_id>delay1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inv_delay</source_block_id><sink_block_id>delay1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inv_delay</source_block_id><sink_block_id>delay3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inv_delay</source_block_id><sink_block_id>delay6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inv_delay</source_block_id><sink_block_id>delay3_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inv_delay</source_block_id><sink_block_id>delay3_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>ir_ref_pulse</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>inv_delay_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inv_delay_3</source_block_id><sink_block_id>inv_delay_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inv_delay_2</source_block_id><sink_block_id>inv_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inv_delay_1</source_block_id><sink_block_id>inv_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inv_delay_0</source_block_id><sink_block_id>inv_delay</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
